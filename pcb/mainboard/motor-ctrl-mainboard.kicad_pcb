# Repository zhang1career/tars-motor-ctrl

File README.md:

# motor-ctrl

STM32F030K6（LQFP-32）三半桥 PMSM 主控：PCB + 固件。Hall 闭环 6-step（`hall6`）仍是回退路径；交付的控制是定点 FOC 电流环 + 速度环（`motor_foc_fx.c`），成绩见 [`docs/report/speed-loop-20260914.md`](docs/report/speed-loop-20260914.md)。

目录布局与 [`tars-io-mux`](../tars-io-mux) 一致，便于复用工具链与协作习惯。

```
motor-ctrl/
├── docs/                     # 设计文档、引脚表、协议说明、测试流程
├── models/captured/          # 实测/示波器采数（非 pcb 内 models）
├── pcb/                      # KiCad 工程与 Gerber 输出
├── sim/                      # MATLAB/Simulink FOC 模型 + codegen_stm32/
├── src/                      # 全部固件源码
│   ├── firmware/stm32f030/   # F030K6 可烧录工程（App / Core / HAL）
│   ├── platforms/stm32f030/  # F030 可复用驱动（hall6 / 开环 / PWM / Hall / tick）
│   └── shared/tnb/           # 与主机共用的 I²C / TNB 协议头文件
└── tools/                    # 主机侧脚本、测试工具
```

MATLAB 模型与 `sim/codegen_stm32/` 浮点代码**不**进默认固件（M0 软浮点放不下 20 kHz）。参数真源是 `sim/mc_params.m`（λ = 6.3 mWb，Kt = 0.0378 N·m/A）；改它不会改芯片上的定点环，除非再跑 `gen_code.m`。

## 快速入口

| 路径 | 说明 |
|------|------|
| [`src/firmware/stm32f030/README.md`](src/firmware/stm32f030/README.md) | 固件构建、烧录、默认参数、测试脚本、已知陷阱 |
| [`src/platforms/stm32f030/README.md`](src/platforms/stm32f030/README.md) | 平台层：hall6 闭环、开环、TIM1 PWM 与控制环 |
| [`src/shared/tnb/README.md`](src/shared/tnb/README.md) | 主机–从机协议真源 |
| [`docs/roadmap.md`](docs/roadmap.md) | FOC / 弱磁 / 动态性能的分阶段路线图与验收判据 |
| [`docs/report/speed-loop-20260914.md`](docs/report/speed-loop-20260914.md) | 速度环交付：λ、Kt、wrap 成绩、转矩曲线 |
| [`docs/measurement-validity.md`](docs/measurement-validity.md) | 实测前自检清单、静默限幅一览、无效实验模式 |

改动 PWM 相关代码前，先读 `src/firmware/stm32f030/README.md` 的
[已知陷阱](src/firmware/stm32f030/README.md#已知陷阱)——低边常通的 `CCR` 取值、中心对齐的
`RCR`、DTG 非线性编码、半桥板 VOUT 电容，这几条都是实测中代价很大才定位的。

## docs/

设计文档、引脚对照、协议说明、测试流程。建议首批文档：

- `pins.md` — F030K6 与半桥板、Hall、分流电阻接线
- `i2c-protocol.md` — 从机寄存器（或 TNB 扩展）与 TARS 主控对接
- `bringup.md` — 上电、SWD、开环与 hall6 闭环验证步骤

## KiCad design pcb/mainboard/motor-ctrl-mainboard.kicad_pcb

Parts:
C1, C4, C35, C37, C38: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2, C3, C6, C7, C10, C11, C12, C13, C23, C24, C25, C26, C27, C28, C29, C30, C31, C33, C34, C36: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C9: 10pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14, C15, C16, C17, C18, C19, C20, C21, C22: 1nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C32: 470nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D4: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2, D3: 1N4148; D_SOD-323_HandSoldering
D5: BAT54; D_SOD-323_HandSoldering
D6: SS34; D_SMB_Handsoldering
D7: SMBJ14A; D_SMB_Handsoldering
D8: PRTR5V0U2X; SOT-143
D9: SMAJ5.0A; D_SMA_Handsoldering
F1: 2A; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
FB1: 600R@100MHz; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
H1, H2, H3: MountingHole_Pad; MountingHole_3.2mm_M3_ISO14580_Pad
H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO14580_Pad; not fitted
J1: PWR_12V; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J2: CTRL_U; PinHeader_1x04_P2.54mm_Vertical
J3: CTRL_V; PinHeader_1x04_P2.54mm_Vertical
J4: CTRL_W; PinHeader_1x04_P2.54mm_Vertical
J5: I_SENSE_U; PinSocket_1x02_P2.54mm_Vertical
J6: I_SENSE_V; PinSocket_1x02_P2.54mm_Vertical
J7: I_SENSE_W; PinSocket_1x02_P2.54mm_Vertical
J8: HALL; PinHeader_1x05_P2.54mm_Vertical
J9: SWD; PinHeader_1x05_P2.54mm_Vertical
J10: I2C; PinHeader_1x04_P2.54mm_Vertical
J11: UP_STREAM; PinSocket_1x02_P2.54mm_Vertical
J12: UART; PinSocket_1x03_P2.54mm_Vertical
J14: OTEMP1; PinHeader_1x02_P2.54mm_Vertical
J15: OTEMP2; PinHeader_1x02_P2.54mm_Vertical
J21: PWR_BRIDGE; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
JP2: BKIN_EN; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP3: BOOT0_SEL; PinHeader_1x02_P2.54mm_Vertical
Q1, Q3: SS8050; SOT-23
Q2: SS8550; SOT-23
R1, R2, R21, R22, R24, R26, R27, R31, R33, R38: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R5, R6, R17, R23, R29: 10R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R13, R14, R15: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8, R9, R35, R36, R37: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11, R12, R16, R40: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18, R20: 4.02k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19: 24.9k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28: 470R; R_2010_5025Metric_Pad1.40x2.65mm_HandSolder
R30: 39k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R32: 68k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R34: 3.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R39: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R41: 13k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R42: 150k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R43, R44: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RT1: 10k NTC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP9, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25: TestPoint; TestPoint_Pad_D1.5mm
U1: STM32F030K6Tx; LQFP-32_7x7mm_P0.8mm
U2, U3, U4: INA240A2D; TSSOP-8_4.4x3mm_P0.65mm
U5: AMS1117-3.3; SOT-223-3_TabPin2
U6, U7: LM339; SOIC-14_3.9x8.7mm_P1.27mm
Y1: 8MHz; Crystal_HC18-U_Vertical

Connections:
+3V3: C2.1, C3.1, C4.1, C10.1, D8.4 (VCC), D9.1 (A1), FB1.1, J8.2, J9.4, J10.2, JP3.1 (A), R2.1, R10.1, R11.1, R12.1, R16.1, R22.1, R26.2, R27.2, R34.1, R40.1, RT1.1, U1.1 (VDD), U1.17 (VDD), U5.2 (VO)
+3V3A: C5.1, C6.1, C11.1, C12.1, C13.1, FB1.2, R18.1, R38.1, R41.1, U1.5 (VDDA), U2.5 (VS), U2.6 (REF2), U3.5 (VS), U3.6 (REF2), U4.5 (VS), U4.6 (REF2)
+12V: C1.1, C25.1, C26.1, C27.1, C35.1, C36.1, C37.1, D2.2 (A), D6.1 (K), J21.2, Q1.3 (C), R24.1, R28.1, R30.1, U5.3 (VI), U6.3 (V+), U7.3 (V+)
/BOOT0: JP3.2 (B), R1.1, U1.31 (BOOT0)
/CP_DRIVE: R25.1, TP2.1 (1_1), U1.21 (PA11)
/HALL_A: C20.1, R13.2, TP21.1 (1_1), U1.26 (PB3)
/HALL_A_RAW: J8.3, R10.2, R13.1
/HALL_B: C21.1, R14.2, TP22.1 (1_1), U1.27 (PB4)
/HALL_B_RAW: J8.4, R11.2, R14.1
/HALL_C: C22.1, R15.2, TP23.1 (1_1), U1.28 (PB5)
/HALL_C_RAW: J8.5, R12.2, R15.1
/I2C_SCL: D8.3 (I/O2), J10.4, R27.1, U1.29 (PB6)
/I2C_SDA: D8.2 (I/O1), J10.3, R26.1, U1.30 (PB7)
/IOUT_U: R7.1, TP14.1 (1_1), U2.8 (OUT), U6.4 (-), U6.7 (+)
/IOUT_V: R8.1, TP15.1 (1_1), U3.8 (OUT), U6.9 (+), U6.10 (-)
/IOUT_W: R9.1, TP16.1 (1_1), U4.8 (OUT), U7.4 (-), U7.7 (+)
/IR_OUT: J9.2, J11.2, R36.2
/ISENSE_U: C17.1, R7.2, TP11.1 (1_1), U1.7 (PA1)
/ISENSE_V: C18.1, R8.2, TP12.1 (1_1), U1.8 (PA2)
/ISENSE_W: C19.1, R9.2, TP13.1 (1_1), U1.9 (PA3)
/ITRIP_HI: C23.1, R18.2, R19.1, TP17.1 (1_1), U6.5 (+), U6.11 (+), U7.5 (+)
/ITRIP_LO: C24.1, R19.2, R20.1, TP18.1 (1_1), U6.6 (-), U6.8 (-), U7.6 (-), U7.8 (-), U7.10 (-)
/NTC: C33.1, R21.1, RT1.2, TP20.1 (1_1), U1.6 (PA0)
/OSC_IN: C9.2, U1.2 (PF0), Y1.1
/OSC_OUT: R4.2, U1.3 (PF1)
/OTEMP1: C30.1, J14.1, R38.2, R39.1, TP24.1 (1_1), U7.11 (+)
/OTEMP2: C31.1, J15.1, R41.2, R42.1, TP25.1 (1_1), U7.9 (+)
/PWM_U_H: J2.2, U1.18 (PA8)
/PWM_U_L: J2.1, U1.13 (PA7)
/PWM_V_H: J3.2, U1.19 (PA9)
/PWM_V_L: J3.1, U1.14 (PB0)
/PWM_W_H: J4.2, U1.20 (PA10)
/PWM_W_L: J4.1, U1.15 (PB1)
/SWCLK: J9.3, J12.2, R35.2
/TP_CYCLE: R37.1, TP1.1 (1_1), U1.25 (PA15)
/USART1_RX: J12.3, R37.2
/VSENSE_12V: C28.1, R30.2, R31.1, TP3.1 (1_1), U1.10 (PA4)
/VSENSE_V_BOOST: C29.1, R32.2, R33.1, TP4.1 (1_1), U1.11 (PA5)
/nFAULT: D5.2 (A), JP2.1 (A), R16.2, U6.1, U6.2, U6.13, U6.14, U7.1, U7.2
/nFAULT_MCU: JP2.2 (B), R22.2, TP19.1 (1_1), U1.12 (PA6)
/nOTEMP: D5.1 (K), R39.2, R40.2, R42.2, TP5.1 (1_1), U1.22 (PA12), U7.13, U7.14
/~NRST: C7.1, J9.5, R2.2, U1.4 (NRST)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.2, C12.2, C13.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, D1.1 (K), D4.1 (K), D7.2 (A2), D8.1 (GND), D9.2 (A2), H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1, J1.1, J2.3, J3.3, J4.3, J8.1, J9.1, J10.1, J11.1, J12.1, J14.2, J15.2, J21.1, Q2.3 (C), Q3.2 (E), R1.2, R20.2, R21.2, R31.2, R33.2, U1.16 (VSS), U1.32 (VSS), U2.1 (NC), U2.4 (GND), U2.7 (REF1), U3.1 (NC), U3.4 (GND), U3.7 (REF1), U4.1 (NC), U4.4 (GND), U4.7 (REF1), U5.1 (GND), U6.12 (V-), U7.12 (V-)
unnamed: C8.2, R4.1, Y1.2
unnamed: D1.2 (A), R24.2
unnamed: C32.1, D2.1 (K), D3.2 (A), TP9.1 (1_1)
unnamed: D4.2 (A), R34.2
unnamed: D6.2 (A), D7.1 (A1), F1.2
unnamed: F1.1, J1.2
unnamed: J5.1, R23.1
unnamed: J5.2, R17.1
unnamed: J6.1, R29.1
unnamed: J6.2, R3.1
unnamed: J7.1, R6.1
unnamed: J7.2, R5.1
unnamed: Q1.1 (B), R43.2
unnamed: C32.2, Q1.2 (E), Q2.2 (E), TP7.1 (1_1)
unnamed: Q2.1 (B), R44.2
unnamed: Q3.1 (B), R25.2
unnamed: Q3.3 (C), R28.2, R43.1, R44.1, TP6.1 (1_1)
unnamed: R36.1, U1.23 (PA13)
unnamed: R35.1, U1.24 (PA14)
unnamed: C14.1, R17.2, U2.2 (IN+)
unnamed: C14.2, R23.2, U2.3 (IN-)
unnamed: C15.1, R3.2, U3.2 (IN+)
unnamed: C15.2, R29.2, U3.3 (IN-)
unnamed: C16.1, R5.2, U4.2 (IN+)
unnamed: C16.2, R6.2, U4.3 (IN-)
V_BOOST: C34.1, C38.1, D3.1 (K), J2.4, J3.4, J4.4, R32.1

Notes on the sheet:
ADC_IN3
实际贴装3.9k
断开，SWD（从 Flash 启动） 闭合，RUN（从 bootloader 启动）
TIM3_CH2
TIM3_CH1
ADC_IN5
TIM1_CH3
TIM1_CH1
ADC_IN0
TIM1_CH4
实际贴装24k
I2C ESD D4 (SDA/SCL/+5V/GND)
TIM1_CH2N
TIM1_CH3N
ADC_IN1
TIM1_BKIN
TIM1_ETR
TIM1_CH1N
ADC_IN4
TIM1_CH2
ADC_IN2

Board: 2 copper layers, 61.0 x 52.1 mm, 148 parts (8 on the bottom side), 69 nets.

## Code that names these connections

File src/firmware/stm32f030/board_pins.h:

#ifndef BOARD_PINS_H
#define BOARD_PINS_H

/*
 * motor-ctrl mainboard v0.1 — STM32F030K6Tx (LQFP-32)
 * Pin map for firmware. Truth source is docs/mainboard-spec.md section 3;
 * keep both in sync with the KiCad schematic.
 */

/* ---- TIM1 half-bridge (3-phase complementary PWM) ---- */
#define BOARD_PWM_U_H_PIN      GPIO_PIN_8   /* PA8  TIM1_CH1  */
#define BOARD_PWM_U_H_PORT     GPIOA
#define BOARD_PWM_U_L_PIN      GPIO_PIN_7   /* PA7  TIM1_CH1N */
#define BOARD_PWM_U_L_PORT     GPIOA

#define BOARD_PWM_V_H_PIN      GPIO_PIN_9   /* PA9  TIM1_CH2  */
#define BOARD_PWM_V_H_PORT     GPIOA
#define BOARD_PWM_V_L_PIN      GPIO_PIN_0   /* PB0  TIM1_CH2N */
#define BOARD_PWM_V_L_PORT     GPIOB

#define BOARD_PWM_W_H_PIN      GPIO_PIN_10  /* PA10 TIM1_CH3  */
#define BOARD_PWM_W_H_PORT     GPIOA
#define BOARD_PWM_W_L_PIN      GPIO_PIN_1   /* PB1  TIM1_CH3N */
#define BOARD_PWM_W_L_PORT     GPIOB

/* ---- Fault inputs (LM339 open-drain wired-OR, 4k7 pull-up to +3V3) ---- */
#define BOARD_NFAULT_PIN       GPIO_PIN_6   /* PA6  TIM1_BKIN ← window comparator
                                             * (overcurrent), via JP2. Low = fault. */
#define BOARD_NFAULT_PORT      GPIOA
#define BOARD_PWM_BKIN_PIN     BOARD_NFAULT_PIN
#define BOARD_PWM_BKIN_PORT    BOARD_NFAULT_PORT

#define BOARD_NOTEMP_PIN       GPIO_PIN_12  /* PA12 ← remote-NTC comparators, TP5.
                                             * Also OR'd into nFAULT through D5, so
                                             * this pin is what tells overtemp from
                                             * overcurrent apart. Low = overtemp. */
#define BOARD_NOTEMP_PORT      GPIOA

/* ---- Charge pump ----
 * PA11 drives Q3's base through R25 2k2, so a floating pin biases the pump
 * half-on. It must be an explicit push-pull output. Keep it LOW: the pump
 * would take V_BOOST to ~21 V, and with no HB-HS zener on the half-bridge
 * boards that overruns the UCC27211 20 V maximum at low duty
 * (mainboard-spec.md section 9.5.4).
 */
#define BOARD_CP_DRIVE_PIN     GPIO_PIN_11  /* PA11 TIM1_CH4 → CP_DRIVE, TP2 */
#define BOARD_CP_DRIVE_PORT    GPIOA

/* ---- ADC (12-bit, reference = VDDA) ---- */
#define BOARD_ADC_NTC_CH       ADC_CHANNEL_0   /* PA0 board NTC, 10k/10k divider */
#define BOARD_ADC_IU_CH        ADC_CHANNEL_1   /* PA1 ISENSE_U ← INA240_U.OUT */
#define BOARD_ADC_IV_CH        ADC_CHANNEL_2   /* PA2 ISENSE_V ← INA240_V.OUT */
#define BOARD_ADC_IW_CH        ADC_CHANNEL_3   /* PA3 ISENSE_W ← INA240_W.OUT */
#define BOARD_ADC_VBUS_CH      ADC_CHANNEL_4   /* PA4 VSENSE_24V, R30 82k / R31 10k */
#define BOARD_ADC_VBOOST_CH    ADC_CHANNEL_5   /* PA5 VSENSE_V_BOOST, R32 18k / R33 1k */

/* Current front end: INA240A2 (gain 50) across the 10 mOhm half-bridge shunt,
 * mid-rail referenced by dividing +3V3A internally.
 *
 * The reference and the ADC share VDDA, so the zero-current code is 2048
 * whatever VDDA does. Do not rescale it by a measured VDDA -- that would
 * reintroduce the error the ratiometric reference cancels. Measured 2026-08-27:
 * 2045 / 2048 / 2048, i.e. -4.9 / 0 / 0 mA of residual offset.
 */
#define BOARD_ISENSE_ZERO_CODE   2048
#define BOARD_ISENSE_GAIN        50
/* R0 on the 24 V half-bridge is 1 mOhm: 16.17 mA per ADC LSB. The LM339
 * window on ISENSE is sized for 10 mOhm, so its trip point is ~10x higher. */
#define BOARD_SHUNT_MILLIOHM     1

/* Divider ratios as integer fractions, for scaling without floating point. */
#define BOARD_VBUS_DIV_NUM       92   /* (82k + 10k) / 10k */
#define BOARD_VBUS_DIV_DEN       10
#define BOARD_VBOOST_DIV_NUM     19   /* (18k + 1k) / 1k */
#define BOARD_VBOOST_DIV_DEN     1

/* ---- Hall (digital, 3.3 V): yellow / green / blue ---- */
#define BOARD_HALL_A_PIN       GPIO_PIN_3   /* PB3 — HALL_A (yellow Ha) */
#define BOARD_HALL_A_PORT      GPIOB
#define BOARD_HALL_B_PIN       GPIO_PIN_4   /* PB4 — HALL_B (green Hb) */
#define BOARD_HALL_B_PORT      GPIOB
#define BOARD_HALL_C_PIN       GPIO_PIN_5   /* PB5 blue Hc */
#define BOARD_HALL_C_PORT      GPIOB

/* ---- I2C1 (TNB / host) ---- */
#define BOARD_I2C_SCL_PIN      GPIO_PIN_6   /* PB6 */
#define BOARD_I2C_SCL_PORT     GPIOB
#define BOARD_I2C_SDA_PIN      GPIO_PIN_7   /* PB7 */
#define BOARD_I2C_SDA_PORT     GPIOB

/* ---- Debug ---- */
#define BOARD_SWDIO_PIN        GPIO_PIN_13  /* PA13 */
#define BOARD_SWCLK_PIN        GPIO_PIN_14  /* PA14 */
#define BOARD_TP_CYCLE_PIN     GPIO_PIN_15  /* PA15 — TP1, net TP_CYCLE (scope strobe) */
#define BOARD_TP_CYCLE_PORT    GPIOA

#endif /* BOARD_PINS_H */

File src/firmware/stm32f030/Core/Src/main.c:

#include "main.h"
#include "motor_app.h"
#include "motor_vsweep.h"
#include "tnb_node.h"
#include "uart_log.h"
#if defined(MOTOR_FOC_FLOAT) && (MOTOR_FOC_FLOAT != 0)
#include "motor_foc.h"
#endif
#if defined(MOTOR_START_BENCH) && (MOTOR_START_BENCH != 0)
#include "ctrl_bench.h"
#endif
#include "motor_pwm.h"
#include "motor_hall.h"
#include "motor_tick.h"
#include "reset_diag.h"
#include "boost.h"

static void SystemClock_Config(void);
static void Watchdog_Init(void);
static void Watchdog_Kick(void) __attribute__((unused));
static void ResetDiag_Boot(void);

volatile uint32_t g_reset_diag[RESET_DIAG_WORDS]
    __attribute__((section(".noinit"), aligned(4), used));

int main(void)
{
  /* HW option-byte IWDG can run before Watchdog_Init; survive long init. */
  IWDG->KR = 0xAAAAU;
  ResetDiag_Boot();
  HAL_Init();
  SystemClock_Config();
  SystemCoreClockUpdate();

#if defined(BOOST_BRINGUP) && (BOOST_BRINGUP != 0)
  /* Motor bridge stays off. PA11 is the boost switch only. */
  Watchdog_Init();
  Boost_Bringup();
#else
  MotorHall_Init();
  MotorPwm_Init();
  MotorTick_Init();
  TnbNode_SampleRails();
  MotorApp_Init();
  Boost_Init();
  TnbNode_Init();
  UartLog_Init();
  Watchdog_Init();
  (void)motor_swd_entry[0];

  /* Charge pump must rise without any host/mot command. Warm the poll loop
   * before while(1) so duty starts stepping immediately after init. */
  {
    uint32_t t0 = HAL_GetTick();

    while ((HAL_GetTick() - t0) < 200U)
    {
      MotorPwm_PollOcpZero();
      Boost_Poll();
      Watchdog_Kick();
    }
  }

#if defined(MOTOR_START_BENCH) && (MOTOR_START_BENCH != 0)
  /* Pure CPU measurement with the motor off. Reached by reset rather than by a
   * gdb call, which docs/roadmap.md 9.5 rules out for measurements. */
  MotorCtrlBench_Run();
#endif

#if defined(MOTOR_AUTO_START) && (MOTOR_AUTO_START != 0)
#if defined(MOTOR_START_FOC_OBSERVE) && (MOTOR_START_FOC_OBSERVE != 0)
  (void)MotorApp_StartFocObserve();
#elif defined(MOTOR_START_DIAG) && (MOTOR_START_DIAG != 0)
  (void)MotorApp_StartDiagStep();
#elif defined(MOTOR_START_HALL6) && (MOTOR_START_HALL6 != 0)
  (void)MotorApp_Start();
#else
  (void)MotorApp_StartOpenloop6();
#endif
#endif

  for (;;)
  {
#if defined(MOTOR_FOC_FLOAT) && (MOTOR_FOC_FLOAT != 0)
    MotorFoc_Step();
#endif
    TnbNode_Task();
    Boost_Poll();
    MotorVsweep_Poll();
    g_reset_diag[RESET_DIAG_MAIN_TICK_SEEN] = g_reset_diag[RESET_DIAG_TICK_TOTAL];
    Watchdog_Kick();
  }
#endif
}

static void ResetDiag_Boot(void)
{
  uint32_t i;

  if (g_reset_diag[RESET_DIAG_MAGIC_I] != RESET_DIAG_MAGIC)
  {
    for (i = 0U; i < RESET_DIAG_WORDS; i++)
    {
      g_reset_diag[i] = 0U;
    }
    g_reset_diag[RESET_DIAG_MAGIC_I] = RESET_DIAG_MAGIC;
  }
  else
  {
    g_reset_diag[RESET_DIAG_TICK_GAP] =
        g_reset_diag[RESET_DIAG_TICK_TOTAL] - g_reset_diag[RESET_DIAG_MAIN_TICK_SEEN];
  }
  g_reset_diag[RESET_DIAG_RCC_CSR] = RCC->CSR;
  RCC->CSR |= RCC_CSR_RMVF;
}

/* HSE 8 MHz × 6. The HAL oscillator call carries every other source and
 * costs more flash than this board uses. */
static HAL_StatusTypeDef clock_hse_pll(void)
{
  uint32_t t0;

  if (__HAL_RCC_GET_SYSCLK_SOURCE() == RCC_SYSCLKSOURCE_STATUS_PLLCLK)
  {
    if ((__HAL_RCC_GET_PLL_OSCSOURCE() == RCC_PLLSOURCE_HSE) &&
        (READ_BIT(RCC->CFGR, RCC_CFGR_PLLMUL) == RCC_PLL_MUL6) &&
        (READ_BIT(RCC->CFGR2, RCC_CFGR2_PREDIV) == RCC_PREDIV_DIV1))
    {
      return HAL_OK;
    }
    return HAL_ERROR;
  }

  __HAL_RCC_HSE_CONFIG(RCC_HSE_ON);
  t0 = HAL_GetTick();
  while (__HAL_RCC_GET_FLAG(RCC_FLAG_HSERDY) == RESET)
  {
    if ((HAL_GetTick() - t0) > HSE_TIMEOUT_VALUE)
    {
      return HAL_TIMEOUT;
    }
  }

  __HAL_RCC_PLL_DISABLE();
  t0 = HAL_GetTick();
  while (__HAL_RCC_GET_FLAG(RCC_FLAG_PLLRDY) != RESET)
  {
    if ((HAL_GetTick() - t0) > PLL_TIMEOUT_VALUE)
    {
      return HAL_TIMEOUT;
    }
  }

  __HAL_RCC_PLL_CONFIG(RCC_PLLSOURCE_HSE, RCC_PREDIV_DIV1, RCC_PLL_MUL6);
  __HAL_RCC_PLL_ENABLE();
  t0 = HAL_GetTick();
  while (__HAL_RCC_GET_FLAG(RCC_FLAG_PLLRDY) == RESET)
  {
    if ((HAL_GetTick() - t0) > PLL_TIMEOUT_VALUE)
    {
      return HAL_TIMEOUT;
    }
  }
  return HAL_OK;
}

static void SystemClock_Config(void)
{
  RCC_ClkInitTypeDef clk = {0};

  /* PF0/PF1 = OSC_IN/OSC_OUT on LQFP-32; GPIO clock required before HSE start. */
  __HAL_RCC_GPIOF_CLK_ENABLE();

  /* If the crystal misses this window, stay on the default HSI 8 MHz so I2C
   * still answers; do not spin the motor. */
  if (clock_hse_pll() != HAL_OK)
  {
    HAL_Delay(80);
    if (clock_hse_pll() != HAL_OK)
    {
      return;
    }
  }

  clk.ClockType = RCC_CLOCKTYPE_SYSCLK | RCC_CLOCKTYPE_HCLK | RCC_CLOCKTYPE_PCLK1;
  clk.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  clk.AHBCLKDivider = RCC_SYSCLK_DIV1;
  clk.APB1CLKDivider = RCC_HCLK_DIV1;
  if (HAL_RCC_ClockConfig(&clk, FLASH_LATENCY_1) == HAL_OK)
  {
    HAL_RCC_EnableCSS();
  }
}

void MotorClock_Retry(void)
{
  RCC_ClkInitTypeDef clk = {0};

  if (SystemCoreClock >= 40000000U)
  {
    return;
  }

  __HAL_RCC_GPIOF_CLK_ENABLE();
  if (clock_hse_pll() != HAL_OK)
  {
    return;
  }
  clk.ClockType = RCC_CLOCKTYPE_SYSCLK | RCC_CLOCKTYPE_HCLK | RCC_CLOCKTYPE_PCLK1;
  clk.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  clk.AHBCLKDivider = RCC_SYSCLK_DIV1;
  clk.APB1CLKDivider = RCC_HCLK_DIV1;
  if (HAL_RCC_ClockConfig(&clk, FLASH_LATENCY_1) == HAL_OK)
  {
    HAL_RCC_EnableCSS();
    SystemCoreClockUpdate();
  }
}

static void Watchdog_Init(void)
{
  /* LSI ~40 kHz / 64, reload 1250 → about 2 s. Independent of SYSCLK.
   * The prescaler update only finishes while LSI is running. Start the
   * watchdog first so that clock is forced on, then apply the 2 s reload. */
  RCC->CSR |= RCC_CSR_LSION;
  while ((RCC->CSR & RCC_CSR_LSIRDY) == 0U)
  {
  }
  IWDG->KR = 0xCCCCU;
  IWDG->KR = 0x5555U;
  IWDG->PR = IWDG_PR_PR_2;
  IWDG->RLR = 1250U;
  while (IWDG->SR != 0U)
  {
    IWDG->KR = 0xAAAAU;
  }
}

static void Watchdog_Kick(void)
{
  IWDG->KR = 0xAAAAU;
}

void Error_Handler(void)
{
  g_reset_diag[RESET_DIAG_FAULT] = 3U;
  g_reset_diag[RESET_DIAG_FAULT_PC] = (uint32_t)__builtin_return_address(0);
#if !defined(BOOST_BRINGUP) || (BOOST_BRINGUP == 0)
  MotorPwm_HardwareSafe();
#endif
  __disable_irq();
  for (;;)
  {
  }
}

File src/platforms/stm32f030/motor_pwm.c (part):

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    Error_Handler();
  }

  /* Pin must be AF2 before BKE: a GPIO/floating PA6 with BKP=low is what
   * locked MOE on TARS (nFAULT had nowhere to go). Here nFAULT is the
   * window comparator through JP2, active low, 4k7 to +3V3. */
  motor_pwm_bkin_pin();
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
int MotorPwm_ArmOutputs(void)
{
  /* V_BOOST (PA5) is in range and nFAULT is high; see mainboard-spec §9.5.5. */
  if (Boost_Ready() == 0U)
  {
    return 0;
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